IMAGE_INSTALL:append_imx8mmevk = " \
	memtester \
	ntp openssh logrotate \
	"
